# Keil uVision project Project.uvprojx, settings and files
target STM32F334x8 (ARM-ADS)
  device: STM32F334K8 STMicroelectronics
  pack: Keil.STM32F3xx_DFP.2.1.0
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: STM32F334x8
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F334x8
  c misc: --C99
  c include: ..\;..\..\..\Libraries\CMSIS\Include;..\..\..\Libraries\CMSIS\Device\ST\STM32F30x\Include;..\..\..\Libraries\STM32F30x_StdPeriph_Driver\inc;..\..\..\Libraries\STM32F30x_I2C_CPAL_Driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --diag_suppress=L6329
  group /MDK-ARM
    ../../../../../lecture_1/Libraries/CMSIS/Device/ST/STM32F30x/Source/Templates/arm/: startup_stm32f303xc.s
  group STM32F30x_StdPeriph_Driver
    ../../../../../lecture_1/Libraries/STM32F30x_StdPeriph_Driver/src/: stm32f30x_fmc.c stm32f30x_rtc.c stm32f30x_flash.c stm32f30x_misc.c stm32f30x_dbgmcu.c stm32f30x_iwdg.c stm32f30x_rcc.c stm32f30x_usart.c stm32f30x_exti.c stm32f30x_wwdg.c stm32f30x_i2c.c stm32f30x_syscfg.c stm32f30x_spi.c stm32f30x_can.c stm32f30x_adc.c stm32f30x_gpio.c stm32f30x_tim.c stm32f30x_crc.c stm32f30x_opamp.c stm32f30x_dma.c stm32f30x_comp.c stm32f30x_pwr.c stm32f30x_dac.c stm32f30x_hrtim.c
  group User
    ../: stm32f30x_it.c system_stm32f30x.c main.c
target STM32F302x8 (ARM-ADS)
  device: STM32F302R8 STMicroelectronics
  pack: Keil.STM32F3xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x00010000) IRAM(0x20000000,0x00004000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F302x8
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F302x8
  c misc: --C99
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --diag_suppress=L6329
target STM32F303xC (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F303VC STMicroelectronics
  pack: Keil.STM32F3xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x00040000) IRAM(0x20000000,0x0000C000) IRAM2(0x10000000,0x00002000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F303xC
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F303xC,USE_STM32303C_EVAL
  c misc: --C99
  c include: ..\;..\..\..\..\..\lecture_1\Libraries\CMSIS\Include;..\..\..\..\..\lecture_1\Libraries\CMSIS\Device\ST\STM32F30x\Include;..\..\..\..\..\lecture_1\Libraries\STM32F30x_StdPeriph_Driver\inc;..\..\..\..\..\lecture_1\Libraries\STM32F30x_I2C_CPAL_Driver\inc;..\..\..\Utilities\STM32_EVAL\Common;..\..\..\Utilities\STM32_EVAL\STM32303C_EVAL
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  memory RVCT10: RAM 0x10000000 size 0x2000
  link misc: --diag_suppress=L6329
target STM32F303xE (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F303VCTx STMicroelectronics
  pack: Keil.STM32F3xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x0000C000) IRAM2(0x10000000,0x00002000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F303xE
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F303xE,USE_STM32303C_EVAL
  c misc: --C99
  c include: ..\;..\..\..\Libraries\CMSIS\Include;..\..\..\Libraries\CMSIS\Device\ST\STM32F30x\Include;..\..\..\Libraries\STM32F30x_StdPeriph_Driver\inc;..\..\..\Libraries\STM32F30x_I2C_CPAL_Driver\inc;..\..\..\Utilities\STM32_EVAL\Common;..\..\..\Utilities\STM32_EVAL\STM32303C_EVAL
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  memory RVCT10: RAM 0x10000000 size 0x2000
  link misc: --diag_suppress=L6329
software components: CMSIS:CORE 5.1.2
